Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-01-22T16:11:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 22 16:11:45 2020 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{5531A669-15C8-41EB-A2B1-68A88099989F}\ifc * Database version: 5507 * Database creation date: Wed Jan 22 16:11:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 22 16:11:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 22 16:11:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7400 Shower system, 7400(2020):7400 Shower system:430101
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints(Type) - ShowerDefaultElevation: 900 mm
Type - Dimensions(Type) - Over Head Shower Size: Ø 200 mm; Projection: 452 mm; ShowerNominalDepth: 545.692 mm; ShowerNominalHeight: 1156.78 mm; ShowerNominalWidth: 291.051 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 7400(2020); ConvergoRefNr: 0087-1911-0015-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Thermostatic shower faucet with spout; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 27/11/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150088216; EN Standard: EN 1111; LVI Number: 6310867; NRF Number: 4202504; RSK Number: 8283037; VVS Number: 722778804
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/7400; Catalog Drawing URL: http://static.oras.com/catdrw/7400; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/7400; FDV Document URL: http://www.oras.com/datasheet/7400/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7400; Group: Shower systems; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 7400 Shower system; Name_en: 7400 Shower system; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package Weight: 4.5 kg; Product Code: 7400; Product Datasheet: http://www.oras.com/datasheet/7400/en; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7400; Product URL: http://static.oras.com/7400; Type Name: 7400 Shower system
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Can be shortened; Connection Size: G3/4; DN Size: DN 15; Flow Rate At 300kPa: 0.00953496 m3/s; Installation and Maintenance: http://static.oras.com/manual/7400; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part;Non-return valve(s); Noise Class: I (ISO 3822); Not Included: Without Couplings; Pressure Loss With Flow 02ls: 170000 Pa; Shower Parts: Shower head;Wall distance adjustable; Shower Spray: Rain; Spare Parts: http://static.oras.com/sp/7400; Temperature: Thermostatic safety stop at 38°C;THERMO COOL
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7400(2020); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7400; Name: 7400 Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 290x545x1155 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7400; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7400 Shower system
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 1.13038 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.183755 m3
Identity Data - Mark: 12
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7400(2020): 7400 Shower system; Family and Type: 7400(2020): 7400 Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7400(2020): 7400 Shower system; Type Id: 7400(2020): 7400 Shower system; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
